PACKAGECONFIG_append = " \
    icu tslib accessibility gstreamer alsa  gles2 \
"

