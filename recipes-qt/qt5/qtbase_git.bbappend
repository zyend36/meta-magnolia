PACKAGECONFIG_append = " accessibility eglfs fontconfig gles2 linuxfb tslib tslib-conf tslib-calibrate"


DEPENDS += "userland"
