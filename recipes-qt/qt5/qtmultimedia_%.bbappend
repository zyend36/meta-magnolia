
PACKAGECONFIG_append = " \
    gstreamer \
"

